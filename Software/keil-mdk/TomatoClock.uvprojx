# Keil uVision project TomatoClock.uvprojx, settings and files
target TomatoClock (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TomatoClock
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ./core/: core_cm3.c startup_stm32f10x_md.s
  group atklib
    ./atklib/delay/: delay.c
    ./atklib/sys/: sys.c
    ./atklib/usart/: usart.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_dac.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c
